do_compile_append() {
	chrpath -d ${S}/blib/arch/auto/XML/Parser/Expat/Expat.so
}
