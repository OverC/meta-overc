FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://builder.cfg"
