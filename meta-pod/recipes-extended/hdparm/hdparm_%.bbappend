# original depended on stat, but we have stat via coreutils
RDEPENDS_wiper = "bash gawk coreutils"
