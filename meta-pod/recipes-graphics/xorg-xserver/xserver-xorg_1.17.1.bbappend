FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-int10-Fix-error-check-for-pci_device_map_legacy.patch"
