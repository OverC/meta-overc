FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://sna-Protect-against-ABI-breakage-in-recent-versions-.patch"
