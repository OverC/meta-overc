RPROVIDES_${PN}-telnet = "telnet"
RPROVIDES_${PN}-rsh = "rsh"
