FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://gnome-disk-utility-fix-build-issues-against-libnotif.patch"
