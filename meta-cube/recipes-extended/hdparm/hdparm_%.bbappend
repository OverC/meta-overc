# original depended on stat, but we have stat via coreutils
RDEPENDS:wiper = "bash gawk coreutils"
