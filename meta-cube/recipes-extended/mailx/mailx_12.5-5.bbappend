# Force override depends from openssl -> openssl10
DEPENDS = "openssl10"
