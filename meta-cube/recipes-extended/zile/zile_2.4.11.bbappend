do_install_prepend() {
	mkdir -p ${D}${libdir}
}
