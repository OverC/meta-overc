PNBLACKLIST[netcat-openbsd] = ""
