inherit systemd

SYSTEMD_SERVICE_${PN} = "upower.service"
