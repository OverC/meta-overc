FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://container-skip-to-dm_end.patch"

