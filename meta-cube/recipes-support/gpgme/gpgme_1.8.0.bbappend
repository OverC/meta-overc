PACKAGECONFIG_pn-gpgme = ""
