inherit setuptools
require python-ansible.inc

RDEPENDS_${PN} += "python-pyyaml python-jinja2 python-modules"
