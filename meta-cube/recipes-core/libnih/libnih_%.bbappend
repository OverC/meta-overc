SRC_URI += "file://Set-pkgconfigdir-to-use-the-proper-libdir.patch \
           "
